FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-${PV}:"

PACKAGECONFIG_append = " avresample"
